# IAR project Backup of sleep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32W108CB ST STM32W108CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..; ..\..\..\simplemac\include; ..\..\..\hal; ..\..\..\hal\micro; ..\..\..\hal\micro\cortexm3; ..\..\..\hal\micro\cortexm3\stm32w108; ..\..\..\hal\micro\cortexm3\compiler
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\..\simplemac\include; ..\..\..\..; ..\..\..\..\hal; ..\..\..\..\HAL\MICRO\CORTEXM3\STM32W108; ..\..\..\..\simplemac; ..\..\..\..\shared
  OBJCOPY.OOCOutputFile: sleep.srec
  ILINK.IlinkOutputFile: identification card-K5.out
  ILINK.IlinkIcfFile: ..\..\..\hal\micro\cortexm3\stm32w108\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: sleep.out
  group (top)
    ../../../hal/micro/cortexm3/stm32w108/: iar-cfg.icf
    Debug/List/: identification card-K5.map
  group hal
    ../../../hal/micro/cortexm3/: adc.c board.c clocks.c context-switch.s79 cstartup_M.s flash.c i2c.c i2c.h mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c spmr.s79 system-timer.c uart.c
    ../../../hal/micro/cortexm3/stm32w108/: low_level_init.c
    ../src/: rfid.c rfid.h
  group simplemac_library
    ../../../simplemac/include/: phy-library.h
    ../../../simplemac/library/: simplemac-library.a
  group sleep
    ../src/: App.c App.h
