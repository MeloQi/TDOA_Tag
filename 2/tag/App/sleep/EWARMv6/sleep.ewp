# IAR project sleep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32W108 ST STM32W108
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..; ..\..\..\simplemac\include; ..\..\..\hal; ..\..\..\hal\micro; ..\..\..\hal\micro\cortexm3; ..\..\..\hal\micro\cortexm3\stm32w108; ..\..\..\hal\micro\cortexm3\compiler
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\..\simplemac\include; ..\..\..\..; ..\..\..\..\hal; ..\..\..\..\HAL\MICRO\CORTEXM3\STM32W108; ..\..\..\..\simplemac; ..\..\..\..\shared
  OBJCOPY.OOCOutputFile: sleep.bin
  ILINK.IlinkOutputFile: sleep.out
  ILINK.IlinkIcfFile: E:\项目\TD_nano\程序\TDOA嵌入式未完成功能实现方案\双向通讯及方向性code\标识卡\5.在4-2的基础上增加距离过滤code\2\标识卡\hal\micro\cortexm3\stm32w108\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: sleep.srec
  group (top)
    ../../../hal/micro/cortexm3/stm32w108/: iar-cfg.icf
    Debug/List/: identification card-K5.map
  group hal
    ../../../hal/micro/cortexm3/: adc.c board.c clocks.c context-switch.s79 cstartup_M.s flash.c i2c.c i2c.h mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c spmr.s79 system-timer.c uart.c
    ../../../hal/micro/cortexm3/stm32w108/: low_level_init.c
    ../src/: rfid.c rfid.h
  group nano
    ../../../nano/: addr.c config.h hwclock.c hwclock.h nnspi.c nnspi.h ntrxdil.c ntrxdil.h ntrxinit.c ntrxiqpar.c ntrxiqpar.h ntrxranging.c ntrxranging.h ntrxtypes.h ntrxutil.c ntrxutil.h OffstMapInit.h
  group simplemac_library
    ../../../simplemac/include/: phy-library.h
    ../../../simplemac/library/: simplemac-library.a
  group sleep
    ../src/: App.c App.h app_adc.c app_adc.h app_sleep.c app_sleep.h card_id.c commu.c commu.h conf.h disp.c disp.h err_check.c err_check.h rang.h startup_info.c startup_info.h sys_time.c sys_time.h System.c System.h zigbee.c zigbee.h
